# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4,__TARGET_FPU_VFP=1
  c include: .\Core;.\System\Delay;.\System\sys;.\System\Usart;.\User;.\Library\inc;.\Hardware\OLED;.\Hardware\MPU6050;.\Hardware\GPIO;.\Hardware\MOTOR;.\Hardware\STEER;.\Hardware\KEY;.\Hardware\EXTI;.\Hardware\Ultrasonic;.\Hardware\Encoder;.\Hardware\MPU6050\eMPL;.\Hardware\NRF24L01;.\Hardware\ADC;.\Hardware\DAC;.\Hardware\AT24CXX;.\Hardware\Drv8825;.\System\Laser;.\System\RS485;.\System\Usart1_DMA;.\System\Usart2_DMA;.\System\Usart3_DMA;.\System\Uart4_DMA;.\System\Uart5_DMA;.\Control\Control;.\Control\Filter;.\Control\OLEDmenu;.\Control\PID;.\Control\Task;.\Control\Parameter;.\Hardware\FreeTimer;.\Control\Timer;.\Hardware\OpenMV;.\Hardware\DMP\driver\eMPL;.\Hardware\DMP\driver\include;.\Hardware\DMP\driver\stm32L;.\Hardware\DMP\eMPL-hal;.\Hardware\DMP\mllite;.\Hardware\DMP\mpl;.\Hardware\I2C;.\Hardware\IMU;.\Hardware\MPU9250;.\DSPLibrary\Include;.\DSPLibrary;.\Hardware\Filter;.\Control\UPmenu;.\Hardware\Step;.\Hardware\GWKJ;.\Hardware\XunJi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ./Core/: startup_stm32f40_41xxx.s
  group Library
    ./Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DSPLibrary
    ./DSPLibrary/: arm_cortexM4lf_math.lib
  group DMP
    ./Hardware/DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Hardware/DMP/driver/stm32L/: log_stm32.c
    ./Hardware/DMP/eMPL-hal/: eMPL_outputs.c
    ./Hardware/DMP/mllite/: results_holder.c start_manager.c storage_manager.c ml_math_func.c mlmath.c mpl.c data_builder.c hal_outputs.c message_layer.c
    ./Hardware/DMP/mpl/: libmpllib.lib
  group System
    ./System/Delay/: Delay.c Delay.h
    ./System/sys/: sys.c sys.h
    ./System/Usart/: Usart.c Usart.h
    ./System/Laser/: Laser.c Laser.h
    ./System/RS485/: RS485.c RS485.h
    ./System/Usart1_DMA/: Usart1_DMA.c Usart1_DMA.h
    ./System/Usart2_DMA/: Usart2_DMA.c Usart2_DMA.h
    ./System/Usart3_DMA/: Usart3_DMA.c Usart3_DMA.h
    ./System/Uart4_DMA/: Uart4_DMA.c Uart4_DMA.h
    ./System/Uart5_DMA/: Uart5_DMA.c Uart5_DMA.h
  group Control
    ./Control/Task/: Test.c Test.h
    ./Control/Timer/: Timer.c Timer.h
    ./Control/OLEDmenu/: OLEDmenu.c OLEDmenu.h
    ./Control/Filter/: Filter.c Filter.h
    ./Control/PID/: PID.c PID.h
    ./Control/Parameter/: Parameter.c Parameter.h
    ./Control/UPmenu/: UPmenu.c UPmenu.h
  group Hardware
    ./Hardware/GPIO/: GPIO.c GPIO.h
    ./Hardware/KEY/: KEY.c KEY.h
    ./Hardware/EXTI/: EXTI.c EXTI.h
    ./Hardware/OLED/: OLED.c OLED.h
    ./Hardware/FreeTimer/: FreeTimer.c FreeTimer.h
    ./Hardware/Motor/: Motor.c Motor.h
    ./Hardware/Encoder/: Encoder.c Encoder.h
    ./Hardware/Ultrasonic/: Ultrasonic.c Ultrasonic.h
    ./Hardware/Steer/: Steer.c Steer.h
    ./Hardware/DRV8825/: Drv8825.c Drv8825.h
    ./Hardware/NRF24L01/: NRF24L01.c NRF24L01.h SPI3.c SPI3.h
    ./Hardware/AT24CXX/: AT24CXX.c AT24CXX.h EEPROM_IIC.c EEPROM_IIC.h
    ./Hardware/ADC/: ADC.c ADC.h
    ./Hardware/DAC/: DAC.c DAC.h
    ./Hardware/OpenMV/: OpenMV.c OpenMV.h
    ./Hardware/I2C/: I2C.c I2C.h
    ./Hardware/MPU9250/: MPU9250.c MPU9250.h
    ./Hardware/IMU/: IMU.c IMU.h
    ./Hardware/Step/: Step.c Step.h
    ./Hardware/GWKJ/: GWKJ.c GWKJ.h
    ./Hardware/XunJi/: XunJi.c XunJi.h
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c
